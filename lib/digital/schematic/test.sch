v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
C {ipin.sym} -10 60 3 0 {name=p5 lab=clk
}
C {iopin.sym} -50 -20 2 0 {name=p2 lab=D}
C {iopin.sym} -50 20 2 0 {name=p3 lab=Dn}
C {iopin.sym} 50 -20 0 0 {name=p7 lab=Q}
C {iopin.sym} 0 -60 3 0 {name=p14 lab=VP}
C {iopin.sym} 50 20 0 0 {name=p12 lab=Qn}
C {iopin.sym} 10 60 1 0 {name=p1 lab=VN}
C {shift_register.sym} -50 60 0 0 {name=X1}
