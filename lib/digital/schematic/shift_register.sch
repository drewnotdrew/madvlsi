v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
N 110 -270 110 -260 {lab=VP}
N 50 -100 100 -100 {lab=clk}
N 100 -120 100 -100 {lab=clk}
N 460 -160 480 -160 {lab=Qn}
N 460 -200 480 -200 {lab=Q}
N 100 -100 400 -100 {lab=clk}
N 400 -120 400 -100 {lab=clk}
N 300 -120 300 -100 {lab=clk}
N 200 -120 200 -100 {lab=clk}
N 120 -120 120 -60 {lab=VN}
N 220 -120 220 -80 {lab=VN}
N 120 -80 220 -80 {lab=VN}
N 220 -80 320 -80 {lab=VN}
N 320 -120 320 -80 {lab=VN}
N 320 -80 420 -80 {lab=VN}
N 420 -120 420 -80 {lab=VN}
N 110 -260 110 -240 {lab=VP}
N 110 -260 410 -260 {lab=VP}
N 410 -260 410 -240 {lab=VP}
N 310 -260 310 -240 {lab=VP}
N 210 -260 210 -240 {lab=VP}
N 480 -160 500 -160 {lab=Qn}
N 480 -200 505 -200 {lab=Q}
C {ipin.sym} 50 -100 0 0 {name=p5 lab=clk
}
C {iopin.sym} 505 -200 0 0 {name=p1 lab=Q}
C {iopin.sym} 500 -160 0 0 {name=p8 lab=Qn}
C {iopin.sym} 60 -200 2 0 {name=p2 lab=D}
C {iopin.sym} 60 -160 2 0 {name=p3 lab=Dn}
C {iopin.sym} 110 -270 3 0 {name=p12 lab=VP}
C {iopin.sym} 120 -60 1 0 {name=p6 lab=VN}
C {csrl_edge.sym} 60 -120 0 0 {name=X1}
C {csrl_edge.sym} 160 -120 0 0 {name=X2}
C {csrl_edge.sym} 260 -120 0 0 {name=X3}
C {csrl_edge.sym} 360 -120 0 0 {name=X4}
